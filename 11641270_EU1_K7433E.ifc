Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: cd7416e6-53ff-46cb-9e51-3d18a2371cb7, NumberOfSaves: 1]
File name: 0001
Time: 2024-10-01T07:48:58+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11641270_EU1_K7433E:36743300_EU1_11641270_K7433E, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, <Unnamed>, z_Miele_Connection_Electric, z_Miele_Design_Glass, z_Miele_Design_Zinc_Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 559 mm; Height: 1395 mm; Depth: 546 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 36743300_EU1_11641270_K7433E; sets with these values: 2

# IfcDistributionPort, Port_353973_1
Description: Flow; FlowDirection: SOURCEANDSINK
